* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* CDL Netlist:                                          *
*                                                       *
* Cell Name  : test_rppoly                              *
* Netlisted  : Sat Mar 19 18:23:21 2016                 *
* PVS Version: 14.14-s507 Mon Mar 30 17:55:00 PDT 2015 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
*.LDD
*.DEVTMPLT 0 MN(nmos_hs) nmos_hs nsd(D) poly_rout(G) nsd(S) pwell(B)
*.DEVTMPLT 1 MN(nmos_hs_top) nmos_hs_top nsd_top(D) poly_top(G) nsd_top(S) back_gate(B)
*.DEVTMPLT 2 MP(pmos_hs) pmos_hs psd(D) poly_rout(G) psd(S) nwell(B)
*.DEVTMPLT 3 MP(pmos_hs_4_top) pmos_hs_top psd_top(D) poly_top(G) psd_top(S)
*.DEVTMPLT 4 RL(rppoly_s) ppoly_res poly_rout(PLUS) poly_rout(MINUS) nwell(B)
*.DEVTMPLT 5 R(resistor) ppoly_res_h poly_rout(PLUS) poly_rout(MINUS) nwell(B)
*.DEVTMPLT 6 C(cmim) mim_cap_top MIM_top(T) met5_top(B)
*.DEVTMPLT 7 L(ind3n30a02g4) ind3n30 metF_ind_orth(PLUS) metF_ind_orth(MINUS)
*.DEVTMPLT 8 L(ind3n60a02g4) ind3n60 metF_ind_orth(PLUS) metF_ind_orth(MINUS)
*.DEVTMPLT 9 ind3n60_1n80a2g4_CT() ind3n60_ct metF_ind_orth(PLUS) metF_ind_orth(MINUS) met5_ind(CT)

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ind3n60_1n80a2g4_CT                         *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ind3n60_1n80a2g4_CT PLUS MINUS CT
.ends ind3n60_1n80a2g4_CT

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: L                                           *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt L PLUS MINUS
.ends L

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: RL                                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt RL PLUS MINUS B
.ends RL

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rppoly$$3                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rppoly$$3 1 2 3
** N=5 EP=3 FDC=1
R0 3 2 6710 L=1.5e-05 W=5e-06 $[resistor] $SUB=1 $X=2140 $Y=-8180 $dt=5
.ends rppoly$$3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: test_rppoly                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt test_rppoly A C D
** N=5 EP=3 FDC=1
X3 D A C rppoly$$3 $T=9050 16850 0 0 $X=5100 $Y=7480
.ends test_rppoly
